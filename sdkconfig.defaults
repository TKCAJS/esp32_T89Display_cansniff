## sdkconfig.defaults
```kconfig
CONFIG_COMPILER_OPTIMIZATION_PERF=y

CONFIG_LV_ATTRIBUTE_FAST_MEM_USE_IRAM=y

CONFIG_ESP_DEFAULT_CPU_FREQ_MHZ_240
```
